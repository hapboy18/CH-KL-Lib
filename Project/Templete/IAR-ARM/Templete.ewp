# IAR project Templete.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\drivers\inc; ..\..\..\Libraries\devices\at24cxx; ..\..\..\Libraries\devices\mag3110; ..\..\..\Libraries\devices\spiflash; ..\..\..\Libraries\devices\led; ..\..\..\Libraries\utilities\chgui; ..\..\..\Libraries\utilities\minishell; ..\..\..\Libraries\znfat; ..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Templete.out
  ILINK.IlinkIcfFile: toolchain\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group devices/at24cxx
    ../../../Libraries/devices/at24cxx/: at24cxx.c
  group devices/led
    ../../../Libraries/devices/led/: led.c
  group devices/mag3110
    ../../../Libraries/devices/mag3110/: mag3110.c
  group devices/spiflash
    ../../../Libraries/devices/spiflash/: spiflash.c
  group drivers
    ../../../Libraries/drivers/src/: adc.c delay.c dma.c gpio.c i2c.c pit.c spi.c sys.c uart.c wdog.c
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: crt0.s startup.c startup_MKL25Z4.s
    ../../../Libraries/startup/DeviceSupport/: system_MKL25Z4.c
  group users
    ../src/: isr.c isr.h main.c test.c
