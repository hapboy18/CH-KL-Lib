# Keil uVision project templete.uvproj, settings and files
target Template (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: templete
  c flags: Optim=1
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\..\..\..\Libraries\drivers\inc;..\..\src;..\..\..\..\Libraries\devices\24LC512;..\..\..\..\Libraries\devices\LED;..\..\..\..\Libraries\devices\MAG3110;..\..\..\..\Libraries\devices\SPIFLASH
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MKL25Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL25Z4.s
  group User
    ../../src/: main.c isr.c test.c
  group drivers
    ../../../../Libraries/drivers/src/: adc.c delay.c dma.c gpio.c i2c.c pit.c spi.c sys.c uart.c wdog.c
  group device
    ../../../../Libraries/devices/24LC512/: at24cxx.c
    ../../../../Libraries/devices/LED/: led.c
    ../../../../Libraries/devices/MAG3110/: mag3110.c
    ../../../../Libraries/devices/SPIFLASH/: spiflash.c
